<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\L432Test1.ewp</path>
  </project>
  <batchBuild />
</workspace>
